# Keil uVision project IAP.uvprojx, settings and files
target BOOTLOADER (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L496VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BootLoader +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx,USE_HAL_DRIVER
  c misc: --C99
  c include: ..\MAIN\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\Drivers\STM32L4xx_HAL_Driver\Inc;..\HardWare\clock\Include;..\HardWare\dataprocess\Include;..\HardWare\iap\Include;..\HardWare\stmflash\Include;..\HardWare\sys\Include;..\HardWare\usart\Include;..\HardWare\aes\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MAIN
    ../MAIN/: main.c stm32l4xx_it.c
  group CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group StartUp
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l496xx.s
  group STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c
  group HardWare
    ../HardWare/clock/: clocks.c
    ../HardWare/dataprocess/: dataprocess.c
    ../HardWare/iap/: iap.c
    ../HardWare/stmflash/: stmflash.c
    ../HardWare/sys/: sys.c
    ../HardWare/usart/: usart.c
    ../HardWare/aes/: aes.c
software components: CMSIS:CORE 5.1.2
